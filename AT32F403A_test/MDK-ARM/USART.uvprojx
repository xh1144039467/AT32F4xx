# Keil uVision project USART.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.6
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template1 +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Inc;..\Driver\AT32F4xx_StdPeriph_Driver\inc;..\Driver\CMSIS\CM4\CoreSupport;..\Driver\CMSIS\CM4\DeviceSupport;..\AT32_Board;..\Inc;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group Application/MDK-ARM
    ../Driver/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403avgt7.s
  group Applica/User
    ../Src/: main.c at32f4xx_it.c test.c usart.c
  group Driver/AT32Periph
    ../Driver/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_usart.c misc.c at32f4xx_rcc.c at32f4xx_gpio.c at32f4xx_dma.c
  group Driver/CMSIS
    ../Src/: system_at32f4xx.c
  group BSP
    ../AT32_Board/: at32_board.c
  group README
    ./: readme.txt
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
